# IAR project libraries.ewp, settings and files
configuration main (ARM)
  General.OGChipSelectEditMenu: nRF52840_xxAA NordicSemi nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NRF52840_XXAA; CONFIG_NFCT_PINS_AS_GPIOS; _AUDIOGUDE_V3_BOARD; DEBUG
  ICCARM.CCIncludePath2: fsm; pwm; spi; usb; main; cmsis; cmsis\device; cmsis\include; board; utils; timer; adc; fsm
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.ADefines: NRF52840_XXAA
  OBJCOPY.OOCOutputFile: audioguide_v2.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: main\main_nRF5x.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    main/: main.cpp main_nRF5x.icf
  group adc
    adc/: ADC.h
  group application
    utils/: utils.c
  group board
    board/: board.h PowerControl.cpp
  group cmsis
    cmsis/: iar_startup_nrf52.s iar_startup_nrf52840.s system_nrf52.c system_nrf52840.c
  group fsm
    fsm/: fifo.h FSMSheduler.cpp StepperFSM.cpp
  group pwm
    pwm/: hwPWM.cpp ledDriver.cpp
  group timer
    timer/: timer.cpp
