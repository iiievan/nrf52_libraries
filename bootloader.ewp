# IAR project bootloader.ewp, settings and files
configuration bootloader (ARM)
  General.OGChipSelectEditMenu: nRF52840_xxAA NordicSemi nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NRF52840_XXAA; CONFIG_NFCT_PINS_AS_GPIOS; BOOTLOADER
  ICCARM.CCIncludePath2: cmsis; cmsis\device; cmsis\include; bootloader
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NRF52840_XXAA
  OBJCOPY.OOCOutputFile: bootloader.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: bootloader\boot_nRF5x.icf
  ILINK.IlinkExtraOptions: --keep __checksum; --keep __firmware_type
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    bootloader/: boot_nRF5x.icf boot_tools.c bootloader.c
  group cmsis
    cmsis/: iar_startup_nrf52.s iar_startup_nrf52840.s system_nrf52.c system_nrf52840.c
